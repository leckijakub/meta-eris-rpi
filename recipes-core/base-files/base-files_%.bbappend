FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

hostname = "eris-beacon"
