DESCRIPTION = "Spinel CLI"
HOMEPAGE = "https://github.com/openthread/pyspinel"
SECTION = "devel/python"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=e910b35b0ef4e1f665b9a75d6afb7709"

inherit pypi setuptools3

SRC_URI[sha256sum] = "0a48ef767bc07485836ba085baf0ad28c0d99aac5e090521b42da55d18f06ca7"
