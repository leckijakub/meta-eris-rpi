FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://boot-time-optimization.cfg \
"
